INITRAMFS_PACKAGES:append:kria = "mac-config"
INITRAMFS_PACKAGES:append:k26-kr = " kernel-modules load-module"
INITRAMFS_PACKAGES:append:k24-kd = " kernel-modules load-module"
